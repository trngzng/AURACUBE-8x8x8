# Keil uVision project rgbCUBE888.uvproj, settings and files
target rgbCUBE888 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rgbCUBE888 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\LIB\inc;..\CORE;..\USER\inc;..\TF\FATFS\src;..\TF\FATFS\exfuns;..\TF\FATFS\src\option;..\TF\SD\SD;..\TF\SD\SPI;..\TF\MALLOC;..\sys;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../USER/: main.c
    ../USER/src/: stm32f10x_it.c system_stm32f10x.c
  group user
    ../USER/src/: ADC.c calculate.c ColourWheel.c CubeFunction.c effects.c fft.c graphics.c IR_NEC.c LED.c snake.c Text.c Time_Show.c Timer.c
  group lib
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group sys
    ../sys/: sys.c
  group fatfs
    ../TF/MALLOC/: malloc.c
    ../TF/FATFS/src/: diskio.c ff.c
    ../TF/FATFS/exfuns/: exfuns.c fattester.c
    ../TF/SD/SD/: MMC_SD.C
    ../TF/SD/SPI/: spi.c
    ../TF/FATFS/src/option/: ccsbcs.c
  group usb_config
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group usb_core
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
